# Keil uVision project 智能家电控制.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能家电控制 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uart.c uart.h delay.h delay.c key.c key.h oled.c oled.h oledfont.h bmp.h
